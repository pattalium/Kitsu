#include "wild_creature_catalog.h"

namespace kitsu868 {
namespace wild {
namespace {

// Owner-private companions are deliberately absent. They may never enter a
// public catalog, encounter table, website unlock, demo, or download surface.
constexpr Creature kCreatures[] = {
    {0x5cac86a3UL, "Frog", signal::Rarity::Common, Portrait::Frog, true},
    {0x13793dc7UL, "Hamster", signal::Rarity::Common, Portrait::Hamster, true},
    {0x7495dbfbUL, "Turtle", signal::Rarity::Common, Portrait::Turtle, true},
    {0x68d9554eUL, "Rabbit", signal::Rarity::Uncommon, Portrait::Rabbit, true},
    {0x5df6be74UL, "Hedgehog", signal::Rarity::Uncommon,
     Portrait::Hedgehog, true},
    {0xe59408e0UL, "Ferret", signal::Rarity::Uncommon, Portrait::Ferret, true},
    {0x29b4b2f7UL, "Otter", signal::Rarity::Rare, Portrait::Otter, true},
    {0x69276d0cUL, "Axolotl", signal::Rarity::Rare, Portrait::Axolotl, true},
    {0x2dfb0797UL, "Chinchilla", signal::Rarity::Rare,
     Portrait::Chinchilla, true},
    {0xc163efedUL, "Raccoon", signal::Rarity::VeryRare, Portrait::Raccoon,
     true},
    {0x374d2540UL, "Capybara", signal::Rarity::VeryRare,
     Portrait::Capybara, true},
    {0x39fc5b1aUL, "Sugar Glider", signal::Rarity::VeryRare,
     Portrait::SugarGlider, true},
    {0x91a2de7bUL, "Red Panda", signal::Rarity::Epic, Portrait::RedPanda,
     true},
    {0xe04ec405UL, "Pangolin", signal::Rarity::Epic, Portrait::Pangolin, true},
    {0x8e0e1b03UL, "Tasmanian Devil", signal::Rarity::Epic,
     Portrait::TasmanianDevil, true},
    {0x533b9b30UL, "Snow Leopard", signal::Rarity::Legendary,
     Portrait::SnowLeopard, true},
    {0x86f3bb5dUL, "Okapi", signal::Rarity::Legendary, Portrait::Okapi, true},
    {0x2d1d89afUL, "Shoebill", signal::Rarity::Legendary,
     Portrait::Shoebill, true},
    {0xa52160c5UL, "Cat Girl", signal::Rarity::Mythical, Portrait::CatGirl,
     true},
    {0xf0f750bdUL, "Rabbit Girl", signal::Rarity::Mythical,
     Portrait::RabbitGirl, true},
    {0x52a1c03aUL, "Deer Girl", signal::Rarity::Mythical,
     Portrait::DeerGirl, true},
};

constexpr uint8_t kFrogPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x38, 0x1c, 0x54, 0x2a, 0xfc, 0x3f,
    0x3c, 0x3c, 0x14, 0x28, 0x86, 0x61, 0x02, 0x40, 0xe4, 0x27,
    0x1c, 0x38, 0x1e, 0x78, 0x12, 0x48, 0x72, 0x4a, 0xa4, 0x2d,
    0xfe, 0x7f, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kRabbitPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x18, 0x07, 0x28, 0x07, 0xb8, 0x06, 0xd8, 0x05,
    0xd8, 0x07, 0x18, 0x03, 0x08, 0x02, 0x98, 0x02, 0x98, 0x03,
    0xf8, 0x02, 0x10, 0x07, 0x10, 0x0d, 0xb0, 0x19, 0xf0, 0x18,
    0xe0, 0x1d, 0xf0, 0x07, 0x00, 0x00,
};
constexpr uint8_t kOtterPortrait[kPortraitBytes] = {
    0x00, 0x00, 0xf8, 0x01, 0xfe, 0x07, 0xfe, 0x07, 0xfe, 0x03,
    0xfe, 0x02, 0x32, 0x03, 0x84, 0x03, 0x84, 0x07, 0xc4, 0x07,
    0xcc, 0x0f, 0xec, 0x0f, 0xfc, 0x0f, 0xfc, 0x3f, 0xdc, 0x7f,
    0xfc, 0x7f, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kRaccoonPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x0c, 0x07, 0xfe, 0x07, 0x6c, 0x06,
    0xf4, 0x04, 0xfa, 0x05, 0xfe, 0x0f, 0xbe, 0x3f, 0x2c, 0x7e,
    0x18, 0x4d, 0x08, 0x7c, 0x10, 0x69, 0x70, 0x59, 0x70, 0x39,
    0xf8, 0x1f, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kRedPandaPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0xf6, 0x00, 0xc6, 0x00, 0xba, 0x03, 0xfe, 0x0f, 0xf6, 0x1f,
    0xfc, 0x7f, 0xf8, 0x7f, 0xfc, 0x77, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kSnowLeopardPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xfc, 0x03, 0xae, 0x03,
    0xf6, 0x03, 0x42, 0x03, 0x4e, 0x12, 0x12, 0x2b, 0xcc, 0x7f,
    0x84, 0x77, 0xc8, 0x7f, 0xb8, 0x7d, 0xac, 0x7f, 0xfc, 0x17,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kCatGirlPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x1c, 0x0e, 0xec, 0x0f, 0x1c, 0x0c, 0x6c, 0x0d,
    0xf4, 0x0b, 0xf4, 0x0b, 0xfc, 0x0f, 0x3c, 0x0f, 0xf8, 0x07,
    0xe0, 0x33, 0xf0, 0x3b, 0xe8, 0x1e, 0x28, 0x1f, 0xf0, 0x0f,
    0xe0, 0x02, 0xf8, 0x07, 0x00, 0x00,
};
constexpr uint8_t kHamsterPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x3c, 0x3c, 0xee, 0x37, 0xda, 0x3b, 0x0e, 0x28,
    0x04, 0x30, 0x36, 0x2c, 0x32, 0x6e, 0x32, 0x4e, 0x86, 0x71,
    0x8e, 0x71, 0x06, 0x60, 0x22, 0x46, 0x72, 0x4e, 0x26, 0x64,
    0x04, 0x30, 0xfc, 0x3f, 0x00, 0x00,
};
constexpr uint8_t kTurtlePortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3c, 0x00,
    0x42, 0x06, 0xc2, 0x19, 0x76, 0x19, 0x4a, 0x2f, 0x66, 0x79,
    0xfc, 0x7f, 0xf8, 0x7f, 0x68, 0x2f, 0xf8, 0x39, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kHedgehogPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xe0, 0x07, 0xf0, 0x1f,
    0xf8, 0x3f, 0xf8, 0x3f, 0xfc, 0x7f, 0xc4, 0x7f, 0x94, 0x7f,
    0x12, 0x7f, 0x0e, 0x7e, 0x78, 0x37, 0xe0, 0x0e, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kFerretPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x24, 0x00,
    0x22, 0x00, 0x0a, 0x00, 0x52, 0x07, 0xfc, 0x0f, 0x3c, 0x18,
    0x38, 0x10, 0x78, 0x1f, 0x7c, 0x2f, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kAxolotlPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x6e, 0x07, 0xfe, 0x07, 0x0e, 0x0f, 0x06, 0x1f, 0xce, 0x76,
    0x8c, 0x41, 0xf8, 0x7f, 0xf8, 0x0f, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kChinchillaPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x8e, 0x03, 0xf2, 0x04, 0x1a, 0x0c,
    0x06, 0x13, 0x04, 0x23, 0xca, 0x42, 0xea, 0x46, 0x24, 0x45,
    0x04, 0x46, 0xbc, 0x44, 0xfc, 0x64, 0x48, 0x24, 0xfc, 0x1e,
    0xfc, 0x07, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kCapybaraPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xf8, 0x00, 0xc8, 0x00,
    0xa6, 0x1f, 0x26, 0x20, 0x06, 0x40, 0x06, 0x40, 0x0c, 0x40,
    0x08, 0x40, 0x70, 0x4f, 0x70, 0x3b, 0xf0, 0x3e, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kSugarGliderPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0xc6, 0x01, 0xfe, 0x06, 0x7e, 0x18, 0xf6, 0x6f, 0xac, 0x5e,
    0xec, 0x57, 0xe6, 0x5a, 0x00, 0x3c, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kPangolinPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0xf8, 0x03, 0xe4, 0x05, 0x1c, 0x0f, 0xfa, 0x1f,
    0xbe, 0x7d, 0xf8, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kTasmanianDevilPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x3e, 0x00, 0x7e, 0x00, 0xfe, 0x07, 0xbe, 0x0f, 0xfe, 0x0f,
    0xe8, 0x1f, 0xf8, 0x7f, 0xf8, 0x2f, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
constexpr uint8_t kOkapiPortrait[kPortraitBytes] = {
    0x00, 0x00, 0xc6, 0x00, 0xee, 0x00, 0xfe, 0x00, 0xfe, 0x00,
    0xfe, 0x00, 0xfe, 0x07, 0xec, 0x1f, 0xfe, 0x3f, 0xfc, 0x7f,
    0xf0, 0x7f, 0xe0, 0x7f, 0xe0, 0x7f, 0xc0, 0x3d, 0xc0, 0x3d,
    0x60, 0x3d, 0xe0, 0x37, 0x00, 0x00,
};
constexpr uint8_t kShoebillPortrait[kPortraitBytes] = {
    0x00, 0x00, 0xe0, 0x03, 0x10, 0x06, 0x50, 0x02, 0xf0, 0x02,
    0xf0, 0x00, 0xd8, 0x01, 0x48, 0x03, 0xb8, 0x04, 0x78, 0x0f,
    0x60, 0x0b, 0xc0, 0x0f, 0xc0, 0x0e, 0xc0, 0x01, 0xc0, 0x02,
    0xe0, 0x03, 0xe0, 0x03, 0x00, 0x00,
};
constexpr uint8_t kRabbitGirlPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x30, 0x06, 0x20, 0x02, 0x70, 0x03, 0x38, 0x0f,
    0x70, 0x07, 0x10, 0x04, 0x48, 0x09, 0xe8, 0x0b, 0x68, 0x0b,
    0xf8, 0x0f, 0x70, 0x07, 0xe0, 0x03, 0x20, 0x0e, 0x30, 0x0e,
    0xe0, 0x07, 0xe0, 0x03, 0x00, 0x00,
};
constexpr uint8_t kDeerGirlPortrait[kPortraitBytes] = {
    0x00, 0x00, 0x18, 0x0c, 0x18, 0x0c, 0xf8, 0x0f, 0x3e, 0x3e,
    0x1e, 0x3c, 0x4c, 0x29, 0x7c, 0x1f, 0xf8, 0x0f, 0xe8, 0x0b,
    0xf8, 0x0f, 0xe0, 0x03, 0x90, 0x0e, 0xb0, 0x0e, 0xf0, 0x07,
    0x80, 0x02, 0xf0, 0x07, 0x00, 0x00,
};

static_assert(sizeof(kCreatures) / sizeof(kCreatures[0]) ==
                  kCatalogCreatureCount,
              "public catalog must contain three creatures per rarity");

}  // namespace

size_t creatureCount() { return sizeof(kCreatures) / sizeof(kCreatures[0]); }

bool creatureAt(size_t index, Creature& output) {
  if (index >= creatureCount()) return false;
  output = kCreatures[index];
  return true;
}

bool creatureByPackId(uint32_t packId, Creature& output) {
  for (const Creature& creature : kCreatures) {
    if (creature.packId == packId) {
      output = creature;
      return true;
    }
  }
  return false;
}

bool creatureForRarity(signal::Rarity rarity, uint32_t selectionEntropy,
                       Creature& output) {
  if (!signal::validRarity(rarity)) return false;
  size_t candidates = 0U;
  for (const Creature& creature : kCreatures) {
    if (creature.rarity == rarity) ++candidates;
  }
  if (candidates == 0U) return false;
  size_t selected = static_cast<size_t>(selectionEntropy % candidates);
  for (const Creature& creature : kCreatures) {
    if (creature.rarity != rarity) continue;
    if (selected-- == 0U) {
      output = creature;
      return true;
    }
  }
  return false;
}

bool portraitBitmap(Portrait portrait, const uint8_t*& output,
                    size_t& outputBytes) {
  output = nullptr;
  outputBytes = 0U;
  switch (portrait) {
    case Portrait::Frog: output = kFrogPortrait; break;
    case Portrait::Hamster: output = kHamsterPortrait; break;
    case Portrait::Turtle: output = kTurtlePortrait; break;
    case Portrait::Rabbit: output = kRabbitPortrait; break;
    case Portrait::Hedgehog: output = kHedgehogPortrait; break;
    case Portrait::Ferret: output = kFerretPortrait; break;
    case Portrait::Otter: output = kOtterPortrait; break;
    case Portrait::Axolotl: output = kAxolotlPortrait; break;
    case Portrait::Chinchilla: output = kChinchillaPortrait; break;
    case Portrait::Raccoon: output = kRaccoonPortrait; break;
    case Portrait::Capybara: output = kCapybaraPortrait; break;
    case Portrait::SugarGlider: output = kSugarGliderPortrait; break;
    case Portrait::RedPanda: output = kRedPandaPortrait; break;
    case Portrait::Pangolin: output = kPangolinPortrait; break;
    case Portrait::TasmanianDevil: output = kTasmanianDevilPortrait; break;
    case Portrait::SnowLeopard: output = kSnowLeopardPortrait; break;
    case Portrait::Okapi: output = kOkapiPortrait; break;
    case Portrait::Shoebill: output = kShoebillPortrait; break;
    case Portrait::CatGirl: output = kCatGirlPortrait; break;
    case Portrait::RabbitGirl: output = kRabbitGirlPortrait; break;
    case Portrait::DeerGirl: output = kDeerGirlPortrait; break;
    default: return false;
  }
  outputBytes = kPortraitBytes;
  return true;
}

}  // namespace wild
}  // namespace kitsu868
